options:
  parameters:
    generate_options: qt_gui
    id: stream
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: uhd_fpga_ddc_0
  id: uhd_fpga_ddc
  parameters:
    CIC_MAX_DECIM: '255'
    NUM_HB: '3'
    NUM_PORTS: '1'
  states: {}
- name: uhd_fpga_ddc_1
  id: uhd_fpga_ddc
  parameters:
    CIC_MAX_DECIM: '255'
    NUM_HB: '3'
    NUM_PORTS: '1'
  states: {}
- name: uhd_fpga_device_bsp_0
  id: uhd_fpga_device_bsp
  parameters:
    DRAM_WIDTH: '64'
    ENABLE_DRAM: 'True'
    NUM_DRAM_BANKS: '1'
    NUM_DRAM_CHANS: '1'
    RF_BW: '200'
    chdr_width: '64'
    default_target: X310_HG
    device: x310
    type: device
  states: {}
- name: uhd_fpga_duc_0
  id: uhd_fpga_duc
  parameters:
    CIC_MAX_INTERP: '255'
    NUM_HB: '3'
    NUM_PORTS: '1'
  states: {}
- name: uhd_fpga_duc_1
  id: uhd_fpga_duc
  parameters:
    CIC_MAX_INTERP: '255'
    NUM_HB: '3'
    NUM_PORTS: '1'
  states: {}
- name: uhd_fpga_radio_0
  id: uhd_fpga_radio
  parameters:
    NIPC: '1'
    NUM_PORTS: '2'
    desc: radio.yml
    enable_adv_clk_ctrl: 'False'
  states: {}
- name: uhd_fpga_radio_0_0
  id: uhd_fpga_radio
  parameters:
    NIPC: '1'
    NUM_PORTS: '2'
    desc: radio.yml
    enable_adv_clk_ctrl: 'False'
  states: {}
- name: uhd_fpga_replay_0
  id: uhd_fpga_replay
  parameters:
    MEM_ADDR_W: '30'
    MEM_DATA_W: '64'
    NUM_PORTS: '2'
    desc: replay.yml
    priority: '99'
    type: block
  states: {}
- name: uhd_fpga_sep_1_0
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_1_1
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}

connections:
- [uhd_fpga_ddc_0, out_, uhd_fpga_replay_0, in_0]
- [uhd_fpga_ddc_1, out_, uhd_fpga_replay_0, in_1]
- [uhd_fpga_device_bsp_0, ce_clk, uhd_fpga_ddc_0, ce_clk]
- [uhd_fpga_device_bsp_0, ce_clk, uhd_fpga_ddc_1, ce_clk]
- [uhd_fpga_device_bsp_0, ce_clk, uhd_fpga_duc_0, ce_clk]
- [uhd_fpga_device_bsp_0, ce_clk, uhd_fpga_duc_1, ce_clk]
- [uhd_fpga_device_bsp_0, dram_clk, uhd_fpga_replay_0, mem_clk]
- [uhd_fpga_device_bsp_0, radio0, uhd_fpga_radio_0, radio]
- [uhd_fpga_device_bsp_0, radio1, uhd_fpga_radio_0_0, radio]
- [uhd_fpga_device_bsp_0, radio_clk, uhd_fpga_radio_0, radio_clk]
- [uhd_fpga_device_bsp_0, radio_clk, uhd_fpga_radio_0_0, radio_clk]
- [uhd_fpga_device_bsp_0, time, uhd_fpga_radio_0, time]
- [uhd_fpga_device_bsp_0, time, uhd_fpga_radio_0_0, time]
- [uhd_fpga_duc_0, out_, uhd_fpga_radio_0, in_0]
- [uhd_fpga_duc_1, out_, uhd_fpga_radio_0, in_1]
- [uhd_fpga_radio_0, ctrlport, uhd_fpga_device_bsp_0, ctrlport_radio0]
- [uhd_fpga_radio_0, out_0, uhd_fpga_ddc_0, in_]
- [uhd_fpga_radio_0, out_1, uhd_fpga_ddc_1, in_]
- [uhd_fpga_radio_0_0, ctrlport, uhd_fpga_device_bsp_0, ctrlport_radio1]
- [uhd_fpga_radio_0_0, out_0, uhd_fpga_sep_1_0, in0]
- [uhd_fpga_radio_0_0, out_1, uhd_fpga_sep_1_1, in0]
- [uhd_fpga_replay_0, axi_ram, uhd_fpga_device_bsp_0, dram]
- [uhd_fpga_replay_0, out_0, uhd_fpga_duc_0, in_]
- [uhd_fpga_replay_0, out_1, uhd_fpga_duc_1, in_]
- [uhd_fpga_sep_1_0, out0, uhd_fpga_radio_0_0, in_0]
- [uhd_fpga_sep_1_1, out0, uhd_fpga_radio_0_0, in_1]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
